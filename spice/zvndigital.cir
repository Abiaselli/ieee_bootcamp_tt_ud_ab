* C:\Users\abias\Downloads\standalonetests\standalonetests\zvndigital.asc
* Generated by LTspice 26.0.1 for Windows.
Cu U VGnd 22u
Cv V VGnd 0.22u
X§U1 N001 V VGnd ZVN3310A ZVN3310A ;§pnba D)G)S
X§U2 N001 N001 Vdd ZVP3310A ZVP3310A ;§pnba D)G)S
X§U3 V N001 Vdd ZVP3310A ZVP3310A ;§pnba D)G)S
X§U4 V U VGnd ZVN3310A ZVN3310A ;§pnba D)G)S
X§U5 V ACK Vc ZVN3310A ZVN3310A ;§pnba D)G)S
X§U6 U U VGnd ZVN3310A ZVN3310A ;§pnba D)G)S
X§U7 U N001 Vdd ZVP3310A ZVP3310A ;§pnba D)G)S
X§U8 U N002 Vd ZVP3310A ZVP3310A ;§pnba D)G)S
X§U9 N003 N005 N004 ZVP3310A ZVP3310A ;§pnba D)G)S
X§U10 N005 V Vdd ZVP3310A ZVP3310A ;§pnba D)G)S
X§U11 REQ N003 VGnd ZVN3310A ZVN3310A ;§pnba D)G)S
X§U12 N005 V VGnd ZVN3310A ZVN3310A ;§pnba D)G)S
X§U13 VGnd N003 N006 ZVN3310A ZVN3310A ;§pnba D)G)S
X§U14 N003 N005 VGnd ZVN3310A ZVN3310A ;§pnba D)G)S
X§U16 N002 ACK N006 ZVN3310A ZVN3310A ;§pnba D)G)S
X§U17 N004 ACK Vdd ZVP3310A ZVP3310A ;§pnba D)G)S
X§U18 N002 ACK Vdd ZVP3310A ZVP3310A ;§pnba D)G)S
C1 REQ VGnd 0.3u
X§U19 REQ N003 Vdd ZVP3310A ZVP3310A ;§pnba D)G)S
.tran 0 30ms 0 500ns
* Spike out
* Post synaptic input
.model Didl D(Ron=0.0001 Roff=100G Vfwd=0)
.include ZVN3310A.sub
.include ZVP3310A.sub
* Library below included based on ModelFile attribute of instance X§U1, X§U4, X§U5, X§U6, X§U11, X§U12, X§U13, X§U14, X§U16 (C:\Users\abias\Downloads\standalonetests\standalonetests\ZVN3310A.asy)
.lib ZVN3310A.sub
* Library below included based on ModelFile attribute of instance X§U2, X§U3, X§U7, X§U8, X§U9, X§U10, X§U17, X§U18, X§U19 (C:\Users\abias\Downloads\standalonetests\standalonetests\ZVP3310A.asy)
.lib ZVP3310A.sub
.backanno
.end
